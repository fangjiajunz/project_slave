# Keil uVision project project_slave.uvprojx, settings and files
target project_slave (5060960::V5.06 update 7 (build 960)::.\ARMCC2)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: project_slave +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/sx126x_driver/src;../Middlewares/u8g2Lib/inc;../Middlewares/MultMenu/application;../Middlewares/MultMenu/disp;../Middlewares/MultMenu/menu;../user;../TinyFrame/ex;../TinyFrame;../user/log;../bsp;../app;..\bsp;..\app\dht11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: e22_hal.c e22_demo.c key.c u8g2_hal.c main.c gpio.c adc.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/sx126x
    ../Drivers/sx126x_driver/src/: sx126x.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/u8g2_lib
    ../Middlewares/u8g2Lib/src/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Middlewares/MultMenu
    ../Middlewares/MultMenu/application/: application.c
    ../Middlewares/MultMenu/disp/: dispDirver.c
    ../Middlewares/MultMenu/menu/: menu.c
    ../app/: font_chinese.h
  group TinyFrame
    ../TinyFrame/: TF_Config.h TF_Integration.c TinyFrame.c TinyFrame.h
    ../TinyFrame/ex/: tf_master.c tf_master.h tf_multinode.h tf_slave.c tf_slave.h
  group user
    ../user/: byte_queue.c byte_queue.h crc16.c crc16.h heap_4.c heap_4.h usb_uart.c usb_uart.h nvm.h nvm2.c
  group log
    ../user/log/: log.c log.h
  group bsp
    ../bsp/: bsp.h config.h bsp_uart_fifo.c bsp_uart_fifo.h
  group app
    ../app/: app.c app.h app_adc.c app_adc.h app_uart.c app_uart.h app_relay.c app_relay.h app_display.c app_display.h app_co2.c app_co2.h app_dht11.c app_dht11.h app_threshold.h app_threshold.c app_threshold_ui.c app_threshold_ui.h app_devctrl_ui.c app_devctrl_ui.h
    ../app/dht11/: driver_dht11.c driver_dht11.h driver_dht11_interface.c driver_dht11_interface.h
software components: CMSIS:CORE 4.3.0
